FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI_append = " file://cdc.cfg"
