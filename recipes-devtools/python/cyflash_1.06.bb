DESCRIPTION = "Cyflash"
HOMEPAGE = "https://pypi.org/project/cyflash/"
SECTION = "devel/python"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f09eb47206614a4954c51db8a94840fa"


SRC_URI[sha256sum] = "636a0081211406f86fd7b757603d0cb49a8dea8005e5bdca0105af69d3975988"

PYPI_PACKAGE = "cyflash"
inherit pypi

CLEANBROKEN = "1"
